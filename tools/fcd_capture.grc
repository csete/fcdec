<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fcd_capture</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile_fc</value></param>
<param><key>value</key><value>prefix + datetime.now().strftime("fcd_iq_fc_%Y%m%d_%H%M%S") + ".raw"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile_sc</value></param>
<param><key>value</key><value>prefix + datetime.now().strftime("fcd_iq_sc_%Y%m%d_%H%M%S") + ".raw"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"/home/alc/sdr/funcube/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rfg</value></param>
<param><key>label</key><value>LNA</value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>-5</value></param>
<param><key>max</key><value>30</value></param>
<param><key>num_steps</key><value>35</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>mixg</value></param>
<param><key>label</key><value>mixer</value></param>
<param><key>value</key><value>12</value></param>
<param><key>min</key><value>4</value></param>
<param><key>max</key><value>12</value></param>
<param><key>num_steps</key><value>2</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>blocks_complex_to_interleaved_short</key>
<param><key>id</key><value>blocks_complex_to_interleaved_short_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>32767</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>RF freq</value></param>
<param><key>value</key><value>145910e3</value></param>
<param><key>min</key><value>145.85e6</value></param>
<param><key>max</key><value>145.95e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>1.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>10</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>win_size</key><value>1000,500</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>recfile_sc</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>fcd_source_c</key>
<param><key>id</key><value>fcd_source_c_0</value></param>
<param><key>device_name</key><value>hw:1</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>lna</key><value>rfg</value></param>
<param><key>mixer</key><value>mixg</value></param>
<param><key>ppm</key><value>-120</value></param>
<param><key>dci</key><value>0.0</value></param>
<param><key>dcq</key><value>0.0</value></param>
<param><key>iq_phase</key><value>0.0</value></param>
<param><key>iq_gain</key><value>1.0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>recfile_fc</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>fcd_source_c_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_interleaved_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_interleaved_short_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fcd_source_c_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fcd_source_c_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
